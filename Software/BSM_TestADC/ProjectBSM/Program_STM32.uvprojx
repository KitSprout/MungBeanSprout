# Keil uVision project Program_STM32.uvprojx, settings and files
target STM32F030F (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: STM32F030F +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,
  c include: ..\;..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\Libraries\STM32F0xx_StdPeriph_Driver\src;..\Program;..\Program\Dirvers;..\Program\Modules;..\Program\Algorithms
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Library
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_rcc.c stm32f0xx_dma.c stm32f0xx_adc.c stm32f0xx_gpio.c stm32f0xx_usart.c
    ../Program/: stm32f0xx_conf.h
  group Driver
    ../Program/Dirvers/: stm32f0_delay.c stm32f0_adc.c stm32f0_usart.c
  group Program
    ../Program/: experiment_stm32f0.c
  group Module
    ../Program/Modules/: module_rs232.c
  group Algorithm
    ../Program/Algorithms/: algorithm_string.c
  group ::Device
    RTE/Device/STM32F030F4/: startup_stm32f030.s system_stm32f0xx.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.4.0
