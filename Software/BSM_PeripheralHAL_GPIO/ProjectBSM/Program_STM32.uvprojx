# Keil uVision project Program_STM32.uvprojx, settings and files
target STM32F030F (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: STM32F030F
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F030x6, ARM_MATH_CM0
  c include: ..\Libraries\CMSIS\Device;..\Libraries\CMSIS\DSP_Lib;..\Libraries\CMSIS\Include;..\Libraries\STM32F0xx_HAL_Driver\Inc;..\Libraries\STM32F0xx_HAL_Driver\Inc\Legacy;..\Program;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../Libraries/CMSIS/Device/: startup_stm32f030x6.s system_stm32f0xx.c
  group Library
    ../Libraries/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_gpio.c
    ../Program/: stm32f0xx_hal_conf.h
  group Driver
    ../Program/drivers/: stm32f0_delay.c stm32f0_msp.c
  group Program
    ../Program/: main.c beanSproutM.c beanSproutM_bsp.c beanSproutM_it.c
